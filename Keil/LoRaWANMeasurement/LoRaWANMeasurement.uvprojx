# Keil uVision project LoRaWANMeasurement.uvprojx, settings and files
target LoRaWANMeasurement (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L052C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LoRaWANMeasurement
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L052xx REGION_CN470 UART_PRINTF LOGLEVEL=LOG_DEBUG USE_DEBUGGER
  c include: ..\..\src;..\..\src\boards\EasyFetch;..\..\src\boards\mcu\stm32;..\..\src\boards\mcu\stm32\cmsis;..\..\src\boards\mcu\stm32\STM32L0xx_HAL_Driver\Inc;..\..\src\mac;..\..\src\mac\region;..\..\src\radio;..\..\src\system;..\..\src\system\crypto;..\..\src\boards\EasyFetch\cmsis;..\..\src\peripherals
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group apps
    ../../src/apps/LoRaWANMeasurement/: main.c
  group boards\LoRaWANMeasurement
    ../../src/boards/EasyFetch/: adc-board.c board.c gpio-board.c i2c-board.c rtc-board.c spi-board.c sx1276-board.c uart-board.c gps-board.c
  group boards\LoRaWANMeasurement\STM32L0xx_HAL_Driver
    ../../src/boards/mcu/stm32/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_comp.c stm32l0xx_hal_comp_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_crc.c stm32l0xx_hal_crc_ex.c stm32l0xx_hal_cryp.c stm32l0xx_hal_cryp_ex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_firewall.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_i2s.c stm32l0xx_hal_irda.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_lcd.c stm32l0xx_hal_lptim.c stm32l0xx_hal_msp_template.c stm32l0xx_hal_pcd.c stm32l0xx_hal_pcd_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rng.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_smartcard.c stm32l0xx_hal_smartcard_ex.c stm32l0xx_hal_smbus.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_tsc.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_wwdg.c stm32l0xx_ll_adc.c stm32l0xx_ll_comp.c stm32l0xx_ll_crc.c stm32l0xx_ll_crs.c stm32l0xx_ll_dac.c stm32l0xx_ll_dma.c stm32l0xx_ll_exti.c stm32l0xx_ll_gpio.c stm32l0xx_ll_i2c.c stm32l0xx_ll_lptim.c stm32l0xx_ll_lpuart.c stm32l0xx_ll_pwr.c stm32l0xx_ll_rcc.c stm32l0xx_ll_rng.c stm32l0xx_ll_rtc.c stm32l0xx_ll_spi.c stm32l0xx_ll_tim.c stm32l0xx_ll_usart.c stm32l0xx_ll_utils.c
  group boards\mcu\stm32
    ../../src/boards/mcu/stm32/: sysIrqHandlers.c utilities.c
  group mac
    ../../src/mac/: LoRaMac.c LoRaMacCrypto.c
  group mac\region
    ../../src/mac/region/: Region.c RegionCN470.c RegionCommon.c
  group radio
    ../../src/radio/sx1276/: sx1276.c
  group system
    ../../src/system/: adc.c delay.c fifo.c gpio.c i2c.c printf.c timer.c uart.c gps.c
  group system\crypto
    ../../src/system/crypto/: cmac.c aes.c
software components: CMSIS:CORE 5.0.1, Device:Startup 1.0.0
